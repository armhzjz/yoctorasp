SRC_URI = "git://github.com/RPi-Distro/firmware-nonfree;branch=buster;protocol=https"
SRCREV = "b66ab26cebff689d0d3257f56912b9bb03c20567"

