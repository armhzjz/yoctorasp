#FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
PACKAGECONFIG = "use-egl kiosk-mode proprietary-codecs"
